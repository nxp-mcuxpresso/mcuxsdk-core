# IAR project libgeneric.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_A5 Freescale VF6xx_A5
  General.CoreVariant: 52
  General.FPU2: 5
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: psp_arm.out
  postbuild: "..\bat\psp_pioneer2_fpga.bat" "..\..\..\lib\pioneer2_fpga.iar\psp\psp_pioneer2_fpga_d.a" IAR
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
