# IAR project generic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL28Z512xxx7 Freescale MKL28Z512xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: CPU_MKL28T512VDC7_CORE0=1; PLATFORM_SDK_ENABLED=1; _DEBUG=1
  ILINK.IlinkOutputFile: generic.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1200; __heap_size__=0x1200
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 39
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: app.srec
