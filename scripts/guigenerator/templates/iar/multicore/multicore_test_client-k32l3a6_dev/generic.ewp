# IAR project generic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: K32W032S1M2_M4 NXP K32W032S1M2_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_K32W032S1M2VPJ_M4
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: generic.out
  ILINK.IlinkKeepSymbols: _hello_world_cm0plus_image
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x2000
  ILINK.IlinkIcfFile: C:\gitRepo\ksdk2.0main\mcu-sdk-2.0\devices\K32W032S1M2\iar\K32W032S1M2xxx_M4_flash - Copy.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; CPU_K32W032S1M2VPJ_M4
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: app.srec
  ILINK.IlinkOutputFile: rpmsg_lite_pingpong_cm4.out
  ILINK.IlinkIcfFile: ../../../../../../devices/K32W032S1M2/iar/K32W032S1M2xxx_M4_flash.icf
