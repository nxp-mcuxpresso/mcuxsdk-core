<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\frdm-k22f120m.ewp</path>
  </project>
  <batchBuild/>
</workspace>


