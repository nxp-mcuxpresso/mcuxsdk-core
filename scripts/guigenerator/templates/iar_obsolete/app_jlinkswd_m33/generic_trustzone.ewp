# IAR project generic_trustzone.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S69J_M33_CORE0 NXP LPC55S69J_M33_CORE0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 7
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: K70_pit_drivers_test.out
  ILINK.IlinkIcfFile: ..\..\..\..\toolchain\iar\config\128KB_RAM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: twrk70f120m.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Freescale\MK70xN1M_12.icf
configuration Int Flash SramData Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: SRAM_DATA_TARGET
  ICCARM.CCOptLevel: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: twrk70f120m.srec
  ILINK.IlinkOutputFile: twrk70f120m.out
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
configuration Int Flash SramData Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: SRAM_DATA_TARGET
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: twrk70f120m.out
  ILINK.IlinkExtraOptions: as above
configuration Int Flash DDRData Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DDR_DATA_TARGET
  ICCARM.CCOptLevel: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: twrk70f120m.out
  ILINK.IlinkExtraOptions: as above
configuration Int Flash DDRData Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DDR_DATA_TARGET
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: twrk70f120m.out
  ILINK.IlinkExtraOptions: as above
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: twrk70f120m.out
  ILINK.IlinkExtraOptions: as above
