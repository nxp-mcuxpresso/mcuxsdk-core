# Keil uVision project frdmk66f.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MK66FN2M0xxx18 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: hello_world
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_MK66FN2M0VMI18, DEBUG, KEIL,FRDM_K66F, TOWER
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_MK66FN2M0VMD18, DEBUG, KEIL, FRDM_K66F180M, FREEDOM
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  link misc: --no_remove
target Release (ARM-ADS)
  device: MK66FN2M0xxx18 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_MK66FN2M0VMI18, NDEBUG, KEIL, FRDM_K66F, FREEDOM
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_MK66FN2M0VMI18, NDEBUG, KEIL,FRDM_K66F, FREEDOM
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  link misc: --no_remove
