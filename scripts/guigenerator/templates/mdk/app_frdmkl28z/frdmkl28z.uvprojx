# Keil uVision project frdmkl28z.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKL28Z512xxx7 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x1FFF8000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: DEBUG __CC_ARM KEIL NDEBUG CPU_MKL28Z512VLL7
  c misc: --library_interface=armcc   --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: ..\..\..\..\..\devices\MKL28Z7\arm\MKL28Z512xxx7_flash.scf
target Release (ARM-ADS)
  device: MKL28Z512xxx7 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: DEBUG __CC_ARM KEIL NDEBUG CPU_MKL28Z512VLL7
  c misc: --library_interface=armcc   --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: ..\..\..\..\..\devices\MKL28Z7\arm\MKL28Z512xxx7_flash.scf
