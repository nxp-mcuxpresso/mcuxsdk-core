# Keil uVision project app_evkmimxrt1170_cm4_itcm_bin_image.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MIMXRT1052DVL6A NXP
  pack: NXP.MIMXRT1052_A0_DFP.10.0.0
  cpu: IRAM(0x00000000,0x020000) IRAM2(0x20000000,0x020000) IROM(0x60000000,0x4000000) XRAM(0x20200000,0x040000) XRAM2(0x80000000,0x02000000) CPUTYPE("Cortex-M4") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: hello_world
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bincombined --bincombined_base=0x1ffe0000 --output=$Lcore1_image.bin !L
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\platform\linker\mdk_arm\KV58F1M024\MKV58F1M0xxx24_flash.sct
target Release (ARM-ADS)
  device: MIMXRT1052DVL6A NXP
  pack: NXP.MIMXRT1052_A0_DFP.10.0.0
  cpu: as above
  output: hello_world
  AfterMake: as above
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
