# Keil uVision project twrk22f120m128r.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MK22FN128xxx10 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) IRAM2(0x1FFFE000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(100000000) ELITTLE
  output: hello_world
  AfterMake: #K\ARM\ARMCLANG\bin\fromelf.exe --m32combined --output=.\UV4Build\@L.srec !L
  AfterMake: #K\ARM\ARMCLANG\bin\fromelf.exe --m32combined --output=.\UV4Build\@L.bin !L
  c flags: Optim=1 wLevel=2
  c define: CPU_MKL03Z16VFK4 DEBUG __CC_ARM KEIL NDEBUG CPU_MKL03Z32VFK4
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ..\..\..\..\platform\linker\mdk_arm\KL03Z4\KL03Z32xxx4_flash.sct
target Release (ARM-ADS)
  device: MK22FN128xxx10 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKL03Z16VFK4 NDEBUG __CC_ARM KEIL CPU_MKL03Z32VFK4
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: as above
