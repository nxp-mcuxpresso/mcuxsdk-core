# Keil uVision project twrkv10z32.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKV10Z32xxx7 Freescale
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x0600) IRAM2(0x1FFFFE00,0x0200) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKL03Z16VFK4 DEBUG __CC_ARM KEIL NDEBUG CPU_MKL03Z32VFK4
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: ..\..\..\..\platform\linker\arm\KV10Z7\KV10Z32xxx7_flash.sct
target Release (ARM-ADS)
  device: MKV10Z32xxx7 Freescale
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKV10Z16VLF7 NDEBUG __CC_ARM KEIL CPU_MKV10Z32VLF7
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: ..\..\..\..\platform\linker\arm\KV10Z7\KV10Z32xxx7_flash.sct
