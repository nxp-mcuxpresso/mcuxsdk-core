# Keil uVision project frdmkv31f.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKV31F512xxx12 Freescale
  pack: NXP.MKV31F51212_DFP.12.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF8000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: hello_world
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MKL03Z16VFK4 DEBUG  KEIL NDEBUG CPU_MKL03Z32VFK4
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ..\..\..\..\platform\linker\mdk_arm\KL03Z4\KL03Z32xxx4_flash.sct
target Release (ARM-ADS)
  device: MKV31F512xxx12 Freescale
  pack: NXP.MKV31F51212_DFP.12.1.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MKL03Z16VFK4 NDEBUG  KEIL CPU_MKL03Z32VFK4
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: as above
