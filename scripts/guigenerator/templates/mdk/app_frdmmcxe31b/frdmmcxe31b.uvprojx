# Keil uVision project frdmmcxe31b.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MCXE31BMPB NXP
  pack: NXP.MCXE31B_DFP.25.06.00
  cpu: IRAM(0x10000000,0x020000) IRAM2(0x20000000,0x010000) IROM(0x00400000,0x400000) XRAM(0x21400000,0x010000) XRAM2(0x00000000,0x8000) XRAM3(0x11400000,0x8000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MCXE247VLQ DEBUG  KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x21400000 size 0x10000
  memory RVCT7: RAM 0x0 size 0x8000
  memory RVCT8: RAM 0x11400000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\..\platform\linker\arm\MCXE247\MCXE247_flash.scf
target Release (ARM-ADS)
  device: MCXE31BMPB NXP
  pack: NXP.MCXE31B_DFP.25.06.00
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MCXE247VLL NDEBUG  KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x21400000 size 0x10000
  memory RVCT7: RAM 0x0 size 0x8000
  memory RVCT8: RAM 0x11400000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\..\platform\linker\arm\MCXE247\MCXE247_flash.scf
