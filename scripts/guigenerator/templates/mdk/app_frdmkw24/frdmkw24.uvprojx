# Keil uVision project frdmkw24.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKW24D512xxx5 Freescale
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x8000) IRAM2(0x1FFF8000,0x8000) CPUTYPE("Cortex-M4") CLOCK(50000000) ELITTLE
  output: hello_world +hex
  c flags: Optim=1 OneElfS=1
  c define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  link misc: --no_remove
target Release (ARM-ADS)
  device: MKW24D512xxx5 Freescale
  cpu: as above
  output: hello_world +hex
  c flags: Optim=4 OneElfS=1
  c define: CPU_MK64FN1M0VMD12, NDEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  link misc: --no_remove
