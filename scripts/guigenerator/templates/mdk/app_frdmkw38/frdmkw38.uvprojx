# Keil uVision project frdmkw38.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKW38A512VFT4 NXP
  pack: Keil.Kinetis_KWxx_DFP.10.0.0
  cpu: IRAM(0x1FFFC000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x10000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKW38A512VFT4 DEBUG __CC_ARM KEIL NDEBUG
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: ..\..\..\..\..\devices\MKW38A4\arm\MKW38A512xxx4_flash.scf
target Release (ARM-ADS)
  device: MKW38A512VFT4 NXP
  pack: Keil.Kinetis_KWxx_DFP.10.0.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKW38A512VFT4 NDEBUG __CC_ARM KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: ..\..\..\..\..\devices\MKW38A4\arm\MKW38A512xxx4_flash.scf
