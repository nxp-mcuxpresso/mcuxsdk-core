# Keil uVision project frdmkl43zkl33z4.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKL33Z64xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.2
  cpu: IROM(0x00000000,0x10000) IRAM(0x1FFFF800,0x800) IRAM2(0x20000000,0x1800) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: DEBUG  KEIL NDEBUG CPU_MKL33Z64VLH4
  c misc: --library_interface=armcc   --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x800
  memory RVCT10: RAM 0x20000000 size 0x1800
  scatter file: ..\..\..\..\..\platform\devices\MKL33Z644\linker\arm\MKL33Z64xxx4_flash.scf
target Release (ARM-ADS)
  device: MKL33Z64xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.2
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: DEBUG  KEIL NDEBUG CPU_MKL33Z64VLH4
  c misc: --library_interface=armcc   --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x800
  memory RVCT10: RAM 0x20000000 size 0x1800
  scatter file: as above
