# Keil uVision project virtual_board.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKV30F128xxx10 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFE000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKV30F128VFM10, DEBUG, __CC_ARM, KEIL, NDEBUG,TWR-KV31F120M,TOWER
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_MKV30F128VFM10 DEBUG __CC_ARM KEIL NDEBUG,TWR-KV31F120M,TOWER
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffe000 size 0x4000
  link misc: --no_remove
target Release (ARM-ADS)
  device: MKV30F128xxx10 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.6.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: as above
  c misc: --c99 --diag_suppress=1296,186
  asm define: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffe000 size 0x4000
  link misc: --no_remove
