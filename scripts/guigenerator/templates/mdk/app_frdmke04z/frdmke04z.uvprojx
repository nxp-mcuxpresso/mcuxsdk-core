# Keil uVision project frdmke04z.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKE04Z8xxx4 NXP
  pack: Keil.Kinetis_KExx_DFP.1.8.0-dev1
  cpu: IRAM(0x1FFFFF00,0x0400) IROM(0x00000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MKE04Z8VFK4, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x1fffff00 size 0x400
  scatter file: ../../../../../devices/MKE04Z4/arm/MKE04Z8xxx4_flash.scf
  link misc: --remove
target Release (ARM-ADS)
  device: MKE04Z8xxx4 NXP
  pack: Keil.Kinetis_KExx_DFP.1.8.0-dev1
  cpu: IRAM(0x1FFFFF00,0x00000400) IROM(0x00000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NDEBUG, CPU_MKE04Z8VFK4, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x1fffff00 size 0x400
  scatter file: ../../../../../devices/MKE04Z4/arm/MKE04Z8xxx4_flash.scf
  link misc: --remove
