# Keil uVision project virtual_board.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKE16F512xxx16 Freescale
  pack: Keil.Kinetis_KExx_DFP.1.4.0-dev1
  cpu: IROM(0x00000000,0x00080000) IROM2(0x10000000,0x00010000) IRAM(0x1FFF8000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKE16F512VLL16, DEBUG,__CC_ARM,KEIL,TWR_KE18F, TOWER
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_MKE16F512VLL16, DEBUG,__CC_ARM,KEIL,TWR_KE18F, TOWER
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x1fff8000 size 0x10000
  link misc: --no_remove
target Release (ARM-ADS)
  device: MKE16F512xxx16 Freescale
  pack: Keil.Kinetis_KExx_DFP.1.4.0-dev1
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKE16F512VLL16, NDEBUG,__CC_ARM,KEIL,TWR_KE18F, TOWER
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_MKE16F512VLL16, NDEBUG,__CC_ARM,KEIL,TWR_KE18F, TOWER
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x1fff8000 size 0x10000
  link misc: --no_remove
