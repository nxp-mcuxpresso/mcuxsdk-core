# Keil uVision project app_frdmmcxc353.uvprojx, settings and files
target Debug (6220000::V6.22::ARMCLANG)
  device: MCXC353MLF NXP
  pack: NXP.MCXC353_DFP.26.06.00
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x020000) CPUTYPE("Cortex-M23") FPU2 CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: CPU_MCXC353VLF DEBUG  KEIL NDEBUG
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\..\..\devices\MCXC353\arm\MCXC353_flash.scf
target Release (ARM-ADS)
  device: MCXC353MLF NXP
  pack: NXP.MCXC353_DFP.26.06.00
  cpu: as above
  output: hello_world
  c flags: Optim=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: CPU_MCXC041VFK NDEBUG  KEIL CPU_MCXC041VFK
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\..\..\devices\MCXC041\arm\MCXC041_flash.scf
