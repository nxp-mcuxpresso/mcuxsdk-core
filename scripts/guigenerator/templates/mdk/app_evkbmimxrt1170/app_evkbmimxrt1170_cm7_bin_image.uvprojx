# Keil uVision project app_evkbmimxrt1170_cm7_bin_image.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x1ffe0000,0x020000) XRAM(0x00000000,0x020000) XRAM2(0x20240000,0x080000) XRAM3(0x202c0000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: hello_world
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bincombined --bincombined_base=0x20340000 --output=$Lcore1_image.bin !L
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: ..\..\..\..\platform\linker\mdk_arm\KV58F1M024\MKV58F1M0xxx24_flash.sct
target Release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: as above
  output: hello_world
  AfterMake: as above
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
