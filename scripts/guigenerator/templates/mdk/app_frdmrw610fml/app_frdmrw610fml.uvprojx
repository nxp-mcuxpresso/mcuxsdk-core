# Keil uVision project app_frdmrw610fml.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: RW610FMLA2AI NXP
  pack: NXP.RW610_DFP.15.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ
  output: hello_world
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT1: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x0 size 0x130000
target Release (6160000::V6.16::ARMCLANG)
  device: RW610FMLA2AI NXP
  pack: NXP.RW610_DFP.15.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ
  output: hello_world
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
