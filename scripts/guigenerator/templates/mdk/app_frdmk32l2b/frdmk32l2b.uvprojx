# Keil uVision project frdmk32l2b.uvprojx, settings and files
target Debug (ARM-ADS)
  device: K32L2B31xxxA Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20005FFF) IROM(0x0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: hello_world
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_K32L2B31VLH0A DEBUG KEIL NDEBUG
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: ..\..\..\..\..\devices\K32L2B31A\arm\K32L2B31xxxA_flash.scf
target Release (ARM-ADS)
  device: K32L2B31xxxA NXP
  cpu: as above
  output: hello_world
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MKL03Z16VFK4 NDEBUG KEIL CPU_MKL03Z32VFK4
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: ..\..\..\..\..\devices\K32L2B31A\arm\K32L2B31xxxA_flash.scf
