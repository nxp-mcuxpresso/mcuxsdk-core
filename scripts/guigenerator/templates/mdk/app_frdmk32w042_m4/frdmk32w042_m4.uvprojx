# Keil uVision project frdmk32w042_m4.uvprojx, settings and files
target Debug (ARM-ADS)
  device: K32W032S1M2xxx:M4 NXP
  pack: Keil.Kinetis_K32W_DFP.1.0.0-dev3
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x08000000,0x00010000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKL03Z16VFK4 DEBUG __CC_ARM KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x8000000 size 0x10000
  scatter file: ..\..\..\..\..\devices\K32W032S1M2\arm\K32W032S1M2xxx_M4_ram.scf
target Release (ARM-ADS)
  device: K32W032S1M2xxx:M4 NXP
  pack: Keil.Kinetis_K32W_DFP.1.0.0-dev3
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKL03Z16VFK4 NDEBUG __CC_ARM KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x8000000 size 0x10000
  scatter file: as above
