# Keil uVision project app_fpga_aphrodite.uvprojx, settings and files
target Debug (ARM-ADS)
  device: LPC6324:M33 NXP
  pack: Keil.LPC_NEXT0_DFP.0.0.1
  cpu: IRAM(0x20040000,0x000C0000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20040000 size 0xc0000
target Release (ARM-ADS)
  device: LPC6324:M33 NXP
  pack: Keil.LPC_NEXT0_DFP.0.0.1
  cpu: as above
  output: hello_world
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20040000 size 0xc0000
