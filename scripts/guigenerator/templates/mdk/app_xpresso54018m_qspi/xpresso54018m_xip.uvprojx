# Keil uVision project xpresso54018m_xip.uvprojx, settings and files
target Debug (ARM-ADS)
  device: LPC54S018J4MET180 NXP
  pack: NXP.LPC54S018M_DFP.13.0.0
  cpu: IRAM(0x00000000,0x030000) IRAM2(0x20000000,0x028000) XRAM(0x40100000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_LPC54114J256_M4,DEBUG,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_LPC54018,DEBUG,KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT6: RAM 0x40100000 size 0x2000
  memory RVCT9: RAM 0x0 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x28000
  link misc: --no_remove
target Release (ARM-ADS)
  device: LPC54S018J4MET180 NXP
  pack: NXP.LPC54S018M_DFP.13.0.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_LPC54114J256_M4,NDEBUG,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_LPC54114J256_M4,NDEBUG,KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT6: RAM 0x40100000 size 0x2000
  memory RVCT9: RAM 0x0 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x28000
  link misc: --no_remove
