# Keil uVision project frdmke02z40m.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKE02Z64xxx4 NXP
  pack: Keil.Kinetis_KExx_DFP.1.8.0-dev1
  cpu: IRAM(0x1FFFFC00,0x1000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_MKL46Z256VLL4 DEBUG  KEIL NDEBUG
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  scatter file: ../../../../../devices/MKE02Z4/arm/MKE02Z64xxx4_flash.scf
target Release (ARM-ADS)
  device: MKE02Z64xxx2 NXP
  pack: Keil.Kinetis_KExx_DFP.1.8.0-dev1
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG,CPU_MKE02Z64VQH4
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  scatter file: ../../../../../devices/MKE02Z4/arm/MKE02Z64xxx4_flash.scf
