# Keil uVision project twrkm34z75m.uvprojx, settings and files
target Debug (6150000::V6.15::ARMCLANG)
  device: MKM34Z256xxx7 NXP
  pack: Keil.Kinetis_KMxx_DFP.1.3.0
  cpu: IRAM(0x1FFFE000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_MK64FN1M0VMD12, DEBUG,KEIL,TWR_K64F120M, TOWER
  c misc: --library_interface=armcc   --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  link misc: --no_remove
target Release (ARM-ADS)
  device: MKM34Z256xxx7 NXP
  pack: Keil.Kinetis_KMxx_DFP.1.3.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_MK64FN1M0VMD12, NDEBUG,KEIL,TWR_K64F120M, TOWER
  c misc: --library_interface=armcc   --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  link misc: --no_remove
