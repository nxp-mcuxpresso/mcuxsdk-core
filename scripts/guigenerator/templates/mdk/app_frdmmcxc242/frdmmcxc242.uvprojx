# Keil uVision project frdmmcxc242.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MCXC242VLH NXP
  pack: NXP.MCXC242_DFP.17.0.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: hello_world
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG  KEIL NDEBUG CPU_MCXC242VLH
  c misc: --library_interface=armcc   --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: ..\..\..\..\..\platform\devices\MCXC242\linker\arm\MCXC242_flash.scf
target Release (ARM-ADS)
  device: MCXC242 NXP
  pack: NXP.MCXC242_DFP.17.0.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG  KEIL NDEBUG CPU_MCXC242VLH
  c misc: --library_interface=armcc   --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: as above
