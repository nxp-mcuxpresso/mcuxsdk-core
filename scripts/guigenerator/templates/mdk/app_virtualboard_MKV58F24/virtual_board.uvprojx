# Keil uVision project virtual_board.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKV58F1M0xxx24 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.6.0
  cpu: IROM(0x10000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x2F000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MKV58F1M0VLL24, DEBUG, __CC_ARM, KEIL,TWR-KV58F220M,TOWER
  c misc: --c99 --diag_suppress=1296,186
  asm define: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x2f000000 size 0x10000
  link misc: --no_remove
target Release (ARM-ADS)
  device: MKV58F1M0xxx24 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.6.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: as above
  c misc: --c99 --diag_suppress=1296,186
  asm define: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x2f000000 size 0x10000
