# Keil uVision project frdmk32l2a4s.uvprojx, settings and files
target Debug (ARM-ADS)
  device: K32L2A41xxxxA NXP
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x1FFF8000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: DEBUG KEIL NDEBUG CPU_K32L2A41VLL1A
  c misc: --library_interface=armcc   --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: ..\..\..\..\..\devices\K32L2A41A\arm\K32L2A41xxxxA_flash.scf
target Release (ARM-ADS)
  device: K32L2A41xxxxA NXP
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: DEBUG KEIL NDEBUG CPU_K32L2A41VLL1A
  c misc: --library_interface=armcc   --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: ..\..\..\..\..\devices\K32L2A41A\arm\K32L2A41xxxxA_flash.scf
