# Keil uVision project app_evk_k32h844p.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKV58F1M0xxx24 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) IRAM2(0x1FFFC000,0x4000) CPUTYPE("Cortex-M7") FPU2 CLOCK(8000000) ELITTLE
  output: hello_world
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MKV58F1M0VLQ24 DEBUG __CC_ARM KEIL NDEBUG CPU_MKV58F1M0VLQ24
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\platform\linker\mdk_arm\KV58F1M024\MKV58F1M0xxx24_flash.sct
target Release (ARM-ADS)
  device: MKV58F1M0xxx24 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) IRAM2(0x1FFFC000,0x4000) CPUTYPE("Cortex-M7") FPU2 CLOCK(120000000) ELITTLE
  output: hello_world
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MKL03Z16VFK4 NDEBUG __CC_ARM KEIL CPU_MKL03Z32VFK4
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: ..\..\..\..\platform\linker\mdk_arm\KL03Z4\KL03Z32xxx4_flash.sct
