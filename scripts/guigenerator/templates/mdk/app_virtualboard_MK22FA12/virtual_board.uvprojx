# Keil uVision project virtual_board.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MK22FN1M0Axxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.3.0
  cpu: IROM(0x00000000,0x00100000) IRAM(0x20000000,0x00010000) IRAM2(0x1FFF0000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  link misc: --no_remove
target Release (ARM-ADS)
  device: MK22FN1M0Axxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.3.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MK64FN1M0VMD12, NDEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_MK64FN1M0VMD12, NDEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  link misc: --no_remove
