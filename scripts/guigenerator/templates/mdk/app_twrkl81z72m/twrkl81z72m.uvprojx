# Keil uVision project twrkl81z72m.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKL82Z128xxx7 Freescale Semiconductor
  pack: Keil.Kinetis_KLxx_DFP.1.7.0-RC1
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20005FFF) IROM(0x0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKL81Z128VMC7 DEBUG __CC_ARM KEIL NDEBUG
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: ..\..\..\..\..\platform\linker\arm\KL81Z7\KL81Z128xxx7_flash.scf
target Release (ARM-ADS)
  device: MKL82Z128xxx7 Freescale Semiconductor
  pack: Keil.Kinetis_KLxx_DFP.1.7.0-RC1
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKL81Z128VMC7 DEBUG __CC_ARM KEIL NDEBUG
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: as above
