# Keil uVision project virtual_board.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKE14Z256xxx7 Freescale
  pack: Keil.Kinetis_KExx_DFP.1.3.0-RC2
  cpu: IROM(0x00000000,0x40000) IROM2(0x10000000,0x08000) IRAM(0x1FFFE000,0x08000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKE14Z256VLL7, DEBUG,__CC_ARM,KEIL,FRDM_KE14Z, FREEDOM
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_MKE14Z256VLL7, DEBUG,__CC_ARM,KEIL,FRDM_KE14Z, FREEDOM
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  link misc: --no_remove
target Release (ARM-ADS)
  device: MKL33Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MK64FN1M0VMD12, NDEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_MK64FN1M0VMD12, NDEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  link misc: --no_remove
