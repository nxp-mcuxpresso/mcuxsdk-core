# Keil uVision project app_xpresso55s36.uvprojx, settings and files
target Debug (6150000::V6.15::ARMCLANG)
  device: LPC55S36JBD100 NXP
  pack: NXP.LPC55S36_DFP.15.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x080000) XRAM(0x20040000,0x4000) XRAM2(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_LPC55S36JBD100, DEBUG,__CC_ARM,KEIL
  asm define: CPU_LPC55S36JBD100, DEBUG,__CC_ARM,KEIL
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x4000000 size 0x8000
target Release (6130001::V6.13.1::.\ARMCLANG)
  device: LPC55S36JBD100 NXP
  pack: NXP.LPC55S36_DFP.15.0.0
  cpu: as above
  output: hello_world
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_LPC55S36JBD100, NDEBUG,__CC_ARM,KEIL
  asm define: CPU_LPC55S36JBD100, NDEBUG,__CC_ARM,KEIL
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x4000000 size 0x8000
