# Keil uVision project hvpkv46f150m.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKV46F256xxx16 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.4.0-RC7
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) IRAM2(0x1FFFC000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKV46F256VLL16 DEBUG  KEIL NDEBUG CPU_MKV46F256VLL16
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: ..\..\..\..\platform\linker\mdk_arm\KV46F25616\KV46F256xxx16_flash.sct
target Release (ARM-ADS)
  device: MKV46F256xxx16 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) IRAM2(0x1FFFC000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKL03Z16VFK4 NDEBUG  KEIL CPU_MKL03Z32VFK4
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: ..\..\..\..\platform\linker\mdk_arm\KL03Z4\KL03Z32xxx4_flash.sct
