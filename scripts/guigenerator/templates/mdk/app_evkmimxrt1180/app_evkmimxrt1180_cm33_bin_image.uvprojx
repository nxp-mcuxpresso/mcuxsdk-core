# Keil uVision project app_evkmimxrt1180_cm33_bin_image.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MIMXRT1189CVM8B:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.17.0.0
  cpu: IRAM(0x20484000,0x07c000) IRAM2(0x20500000,0x040000) IROM(0x00000000,0x028000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: hello_world
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bincombined --bincombined_base=0x20200000 --output=$Lcore1_image.bin !L
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
  scatter file: ..\..\..\..\platform\linker\mdk_arm\KV58F1M024\MKV58F1M0xxx24_flash.sct
target Release (ARM-ADS)
  device: MIMXRT1189CVM8B:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.17.0.0
  cpu: as above
  output: hello_world
  AfterMake: as above
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
