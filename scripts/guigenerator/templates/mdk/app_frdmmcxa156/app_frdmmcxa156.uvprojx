# Keil uVision project app_frdmmcxa156.uvprojx, settings and files
target Debug (6180000::V6.18::ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.17.0.0
  cpu: IRAM(0x20000000,0x01e000) IRAM2(0x04000000,0x3000) IROM(0x03000000,0x2000) IROM2(0x13000000,0x2000) XROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
target Release (6130001::V6.13.1::.\ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.17.0.0
  cpu: as above
  output: hello_world
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
