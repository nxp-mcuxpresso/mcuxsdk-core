# Keil uVision project frdmmcxc444.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MCXC444VLH NXP
  pack: NXP.MCXC444_DFP.17.0.0
  cpu: IRAM(0x1fffe000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MCXC444VLH DEBUG  KEIL NDEBUG
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: ..\..\..\..\..\devices\MCXC444\arm\MCXC444_flash.scf
target Release (ARM-ADS)
  device: MCXC444VLH NXP
  pack: NXP.MCXC444_DFP.17.0.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MKL03Z16VFK4 NDEBUG  KEIL CPU_MKL03Z32VFK4
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: ..\..\..\..\..\platform\linker\arm\KL43Z4\KL43Z256xxx4_flash.scf
