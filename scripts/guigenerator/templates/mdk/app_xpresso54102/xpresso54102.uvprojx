# Keil uVision project xpresso54102.uvprojx, settings and files
target Debug (ARM-ADS)
  device: LPC54113J128BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.4.0-dev0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x02000000,0x00020000) IRAM2(0x20020000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: DEBUG,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: DEBUG,KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x02000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  link misc: --no_remove
target Release (ARM-ADS)
  device: LPC54113J128BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.4.0-dev0
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: NDEBUG,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: NDEBUG,KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x02000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  link misc: --no_remove
