# Keil uVision project 845breakout.uvprojx, settings and files
target Debug (ARM-ADS)
  device: LPC844M201JBD64 NXP
  pack: Keil.LPC800_DFP.1.7.0
  cpu: IROM(0x00000000,0x00010000) IRAM(0x10000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: DEBUG,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: DEBUG,__CC_ARM,KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  link misc: --no_remove
target Release (ARM-ADS)
  device: LPC845M301JBD64 NXP
  pack: Keil.LPC800_DFP.1.7.0
  cpu: IROM(0x00000000,0x00010000) IRAM(0x10000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_LPC845M301, NDEBUG,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_LPC845M301, NDEBUG,__CC_ARM,KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x4000
  link misc: --no_remove
