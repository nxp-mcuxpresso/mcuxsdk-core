# Keil uVision project frdmke17z.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKE15Z256xxx7 Freescale
  pack: Keil.Kinetis_KExx_DFP.1.4.0
  cpu: IROM(0x00000000,0x40000) IROM2(0x10000000,0x08000) IRAM(0x1FFFE000,0x08000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKL46Z256VLL4 DEBUG  KEIL NDEBUG
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: ..\..\..\..\..\platform\linker\arm\KL46Z4\KL46Z256xxx4_flash.scf
target Release (ARM-ADS)
  device: MKE15Z256xxx7 Freescale
  pack: Keil.Kinetis_KExx_DFP.1.4.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKL03Z16VFK4 NDEBUG  KEIL CPU_MKL03Z32VFK4
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: as above
