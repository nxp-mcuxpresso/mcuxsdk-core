# Keil uVision project frdmkw36.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKW36Z512xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.6.0-dev4
  cpu: IRAM(0x1FFFC000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x10000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKW36Z512VHT4 DEBUG __CC_ARM KEIL NDEBUG
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: ..\..\..\..\..\platform\linker\arm\KW36Z4\KW36Z512xxx4_flash.scf
target Release (ARM-ADS)
  device: MKW36Z512xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.6.0-dev4
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKW36Z512VHT4 NDEBUG __CC_ARM KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: as above
