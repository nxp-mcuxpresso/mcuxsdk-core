# Keil uVision project app_pnev76fama.uvprojx, settings and files
target Debug (6120000::V6.12::.\ARMCLANG)
  device: PN7640EV:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: IRAM(0x20003000,0x5000) IRAM2(0x20008100,0x940) IROM(0x00218000,0x1E000) CPUTYPE("Cortex-M33") TZ CLOCK(45000000) ELITTLE
  output: hello_world
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x218000 size 0x1e000
  memory RVCT9: RAM 0x20003000 size 0x5000
  memory RVCT10: RAM 0x20008100 size 0x940
target Release (6120000::V6.12::.\ARMCLANG)
  device: PN7640EV:cm33 NXP
  pack: NXP.MIMXRT595S_DFP.12.0.0
  cpu: as above
  output: hello_world
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT1: ROM 0 size 0
  memory RVCT2: ROM 0 size 0
  memory RVCT3: ROM 0 size 0
  memory RVCT4: ROM 0x218000 size 0x1e000
  memory RVCT5: ROM 0 size 0
  memory RVCT6: RAM 0 size 0
  memory RVCT7: RAM 0 size 0
  memory RVCT8: RAM 0 size 0
  memory RVCT9: RAM 0x20003000 size 0x5000
  memory RVCT10: RAM 0x20008100 size 0x940
