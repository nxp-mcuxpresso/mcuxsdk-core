# Keil uVision project usbkw41z_kw41z.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKW41Z512xxx4 Freescale Semiconductor
  pack: Keil.Kinetis_KWxx_DFP.1.4.0-dev0
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20005FFF) IROM(0x0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKW41Z512VHT4 DEBUG __CC_ARM KEIL NDEBUG
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: ..\..\..\..\..\platform\linker\arm\KW41Z4\KW41Z512xxx4_flash.scf
target Release (ARM-ADS)
  device: MKW41Z512xxx4 Freescale Semiconductor
  pack: Keil.Kinetis_KWxx_DFP.1.4.0-dev0
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKL03Z16VFK4 NDEBUG __CC_ARM KEIL CPU_MKL03Z32VFK4
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: as above
