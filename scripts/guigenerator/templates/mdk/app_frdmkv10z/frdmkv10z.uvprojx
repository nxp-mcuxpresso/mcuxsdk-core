# Keil uVision project frdmkv10z.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKV10Z32xxx7 Freescale
  cpu: IROM(0x00000000,0x8000) IRAM(0x1FFFF800,0x2000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: DEBUG, CPU_MKV10Z32VLF7, FRDM_KV10Z
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1FFFF800 size 0x2000
  scatter file: ..\..\..\..\platform\linker\arm\KV10Z7\KV10Z32xxx7_flash.sct
target Release (ARM-ADS)
  device: MKV10Z32xxx7 Freescale
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKV10Z16VLF7 NDEBUG __CC_ARM KEIL CPU_MKV10Z32VLF7
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1FFFF800 size 0x2000
  scatter file: ..\..\..\..\platform\linker\arm\KV10Z7\KV10Z32xxx7_flash.sct
