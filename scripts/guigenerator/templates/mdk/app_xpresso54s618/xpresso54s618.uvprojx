# Keil uVision project xpresso54s618.uvprojx, settings and files
target Debug (ARM-ADS)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.4.0-dev0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20010000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: DEBUG,__CC_ARM,KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  link misc: --no_remove
target Release (ARM-ADS)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.4.0-dev0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  link misc: --no_remove
