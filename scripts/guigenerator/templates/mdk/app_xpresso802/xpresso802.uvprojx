# Keil uVision project xpresso802.uvprojx, settings and files
target Debug (ARM-ADS)
  device: LPC802M001JDH20 NXP
  pack: NXP.LPC802_DFP.19.0.0
  cpu: IROM(0x00000000,0x00004000) IRAM(0x10000000,0x00000800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: DEBUG,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: DEBUG,__CC_ARM,KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x800
  link misc: --no_remove
target Release (ARM-ADS)
  device: LPC845M301JHI48 NXP
  pack: NXP.LPC845_DFP.19.0.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M0+") FPU2 CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_LPC845M301, NDEBUG,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_LPC845M301, NDEBUG,__CC_ARM,KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  link misc: --no_remove
