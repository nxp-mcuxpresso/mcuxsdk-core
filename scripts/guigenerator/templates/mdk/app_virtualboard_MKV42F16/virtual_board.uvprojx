# Keil uVision project virtual_board.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKV42F256xxx16 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x1FFFC000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MKV42F256VLL16, DEBUG, __CC_ARM, KEIL,TWR-KV46F150,TOWER
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_MKV42F256VLL16, DEBUG, __CC_ARM, KEIL,TWR-KV46F150,TOWER
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x8000
  link misc: --no_remove
target Release (ARM-ADS)
  device: MKV42F256xxx16 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.6.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKV42F256VLL16 DEBUG __CC_ARM KEIL NDEBUG,TWR-KV46F150M,TOWER
  c misc: --c99 --diag_suppress=1296,186
  asm define: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x8000
