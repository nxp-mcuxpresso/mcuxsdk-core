# Keil uVision project 8n04devboard.uvprojx, settings and files
target Debug (ARM-ADS)
  device: LPC8N04FHI24 NXP
  pack: Keil.LPC800_DFP.1.7.0
  cpu: IRAM(0x10000000,0x00002000) IROM(0x00000000,0x00007800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: DEBUG,__CC_ARM,KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x7800
  memory RVCT9: RAM 0x10000000 size 0x2000
  link misc: --no_remove
target Release (ARM-ADS)
  device: LPC8N04FHI24 NXP
  pack: Keil.LPC800_DFP.1.7.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_LPC845M301,NDEBUG,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_LPC845M301,__CC_ARM,NDEBUG,KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x7800
  memory RVCT9: RAM 0x10000000 size 0x2000
  link misc: --no_remove
