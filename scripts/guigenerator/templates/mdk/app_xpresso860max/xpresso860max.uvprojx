# Keil uVision project xpresso860max.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: LPC865M201JBD64 NXP
  pack: NXP.LPC865_DFP.13.0.0
  cpu: IRAM(0x10001fe0,0x20) IRAM2(0x10000000,0x1fe0) IROM(0x00000000,0x010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: DEBUG,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: DEBUG,__CC_ARM,KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x1fe0
  memory RVCT10: RAM 0x10001fe0 size 0x20
  link misc: --no_remove
target Release (6160000::V6.16::ARMCLANG)
  device: LPC865M201JBD64 NXP
  pack: NXP.LPC865_DFP.13.0.0
  cpu: IROM(0x00000000,0x00010000) IRAM(0x10000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_LPC865M201, NDEBUG,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_LPC865M201, NDEBUG,__CC_ARM,KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x1fe0
  memory RVCT10: RAM 0x10001fe0 size 0x20
  link misc: --no_remove
