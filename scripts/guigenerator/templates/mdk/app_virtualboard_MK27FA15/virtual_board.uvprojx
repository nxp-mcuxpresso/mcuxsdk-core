# Keil uVision project virtual_board.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MK27FN2M0Axxx15 NXP
  pack: Keil.Kinetis_K20_DFP.1.5.0-dev1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x1FFC0000,0x00040000) IROM(0x00000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MK27FN2M0AVMI15 DEBUG __CC_ARM KEIL NDEBUG CPU_MK28FN2M0AVMI15
  c misc: --c99 --diag_suppress=1296,186
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x1ffc0000 size 0x40000
target Release (ARM-ADS)
  device: MK27FN2M0Axxx15 NXP
  pack: Keil.Kinetis_K20_DFP.1.5.0-dev1
  cpu: as above
  output: hello_world
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MK27FN2M0AVMI15 NDEBUG __CC_ARM KEIL CPU_MK28FN2M0AVMI15
  c misc: --c99 --diag_suppress=1296,186
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x1ffc0000 size 0x40000
