# Keil uVision project app_frdmmcxn236.uvprojx, settings and files
target Debug (6180000::V6.18::ARMCLANG)
  device: MCXN236VDF NXP
  pack: NXP.MCXN236_DFP.17.0.0
  cpu: IRAM(0x20000000,0x040000) IRAM2(0x04000000,0x018000) IROM(0x03000000,0x040000) IROM2(0x13000000,0x040000) XRAM(0x14000000,0x018000) XRAM2(0x30000000,0x040000) XROM(0x00000000,0x080000) XROM2(0x00080000,0x080000) XROM3(0x10000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT2: ROM 0x80000 size 0x80000
  memory RVCT3: ROM 0x10000000 size 0x80000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x14000000 size 0x18000
  memory RVCT7: RAM 0x30000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x4000000 size 0x18000
target Release (6130001::V6.13.1::.\ARMCLANG)
  device: MCXN236VDF NXP
  pack: NXP.MCXN236_DFP.17.0.0
  cpu: IRAM(0x20000000,0x038000) IRAM2(0x04000000,0x018000) IROM(0x03000000,0x040000) IROM2(0x13000000,0x040000) XRAM(0x14000000,0x018000) XRAM2(0x30000000,0x038000) XROM(0x00000000,0x080000) XROM2(0x00080000,0x080000) XROM3(0x10000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT2: ROM 0x80000 size 0x80000
  memory RVCT3: ROM 0x10000000 size 0x80000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x14000000 size 0x18000
  memory RVCT7: RAM 0x30000000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0x38000
  memory RVCT10: RAM 0x4000000 size 0x18000
