# Keil uVision project xpresso54018.uvprojx, settings and files
target Debug (ARM-ADS)
  device: LPC54018JET180:M4 NXP
  pack: NXP.LPC54018_DFP.2.3.0
  cpu: IRAM(0x00000000,0x00030000) IRAM2(0x20000000,0x00028000) IROM(0x10000000,0x1000000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_LPC54114J256_M4, DEBUG,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: DEBUG,__CC_ARM,KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x1000000
  memory RVCT9: RAM 0x0 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x28000
  link misc: --no_remove
target Release (ARM-ADS)
  device: LPC54018JET180:M4 NXP
  pack: NXP.LPC54018_DFP.2.3.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_LPC54114J256_M4, NDEBUG,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x1000000
  memory RVCT9: RAM 0x0 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x28000
  link misc: --no_remove
