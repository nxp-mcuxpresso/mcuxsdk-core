# Keil uVision project frdmkl25z.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKL25Z128VLK4 DEBUG __CC_ARM KEIL NDEBUG
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: ..\..\..\..\..\platform\devices\MKL25Z4\linker\arm\KL25Z128xxx4_flash.scf
target Release (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKL25Z128VLK4 DEBUG __CC_ARM KEIL NDEBUG
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: as above
