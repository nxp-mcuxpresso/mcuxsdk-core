# Keil uVision project frdmkw019032.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKW01Z128xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.3.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKW01Z128CHN4 DEBUG __CC_ARM KEIL NDEBUG
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1ffff000 size 0x1000
  scatter file: ..\..\..\..\..\platform\devices\MKW01Z4\linker\arm\KW01Z128xxx4_flash.scf
target Release (ARM-ADS)
  device: MKW01Z128xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.3.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MKL03Z16VFK4 NDEBUG __CC_ARM KEIL CPU_MKL03Z32VFK4
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: as above
