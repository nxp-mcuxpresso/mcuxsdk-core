# Keil uVision project frdmke06z.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKE06Z128xxx4 NXP
  pack: Keil.Kinetis_KExx_DFP.1.8.0-dev1
  cpu: IRAM(0x1FFFF000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_MKE06Z128VLK4, DEBUG  KEIL NDEBUG
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: ../../../../../devices/MKE06Z4/arm/MKE06Z128xxx4_flash.scf
target Release (ARM-ADS)
  device: MKE06Z128xxx4 NXP
  pack: Keil.Kinetis_KExx_DFP.1.8.0-dev1
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_MKE06Z128VLK4, NDEBUG  KEIL CPU_MKL03Z32VFK4
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: ../../../../../devices/MKE06Z4/arm/MKE06Z128xxx4_flash.scf
