# Keil uVision project frdmk32l3a6_m0p_bin_image_ram_testing.uvprojx, settings and files
target Debug (ARM-ADS)
  device: K32L3A60xxx:M0P NXP
  pack: Keil.Kinetis_K32L_DFP.1.0.0-dev3
  cpu: IRAM(0x09000000,0x00020000) IROM(0x01000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hello_world
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bincombined --bincombined_base=0x09000000 --output=$Lcore1_image.bin !L
  c flags: Optim=1 wLevel=2
  c define: DEBUG  KEIL NDEBUG CPU_MKL28Z512VLL7
  c misc: --library_interface=armcc   --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x9000000 size 0x20000
  scatter file: ..\..\..\..\..\devices\K32L3A60\arm\K32L3A60xxx_M0P_ram.scf
target Release (ARM-ADS)
  device: K32L3A60xxx:M0P NXP
  pack: Keil.Kinetis_K32W_DFP.1.0.0-dev3
  cpu: as above
  output: hello_world
  AfterMake: as above
  c flags: Optim=1 wLevel=2
  c define: DEBUG  KEIL NDEBUG CPU_MKL28Z512VLL7
  c misc: --library_interface=armcc   --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x9000000 size 0x20000
  scatter file: ..\..\..\..\..\devices\K32L3A60\arm\K32L3A60xxx_M0P_ram.scf
