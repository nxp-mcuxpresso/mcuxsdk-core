# Keil uVision project qn908x.uvprojx, settings and files
target Debug (ARM-ADS)
  device: QN9080C NXP
  pack: Keil.QN908x_DFP.1.1.1
  cpu: IROM(0x00000000,0x40000) IROM2(0x00000000,0x00000) IRAM(0x04000400,0xFC00) IRAM2(0x00000000,0x00000) CPUTYPE("Cortex-M4") FPU2 CLOCK(16000000) ELITTLE
  output: hello_world
  AfterMake: fromelf.exe --bin -o "output\@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x4000400 size 0xfc00
  link misc: --no_remove
target Release (ARM-ADS)
  device: QN9080C NXP
  pack: Keil.QN908x_DFP.1.1.1
  cpu: as above
  output: hello_world
  AfterMake: fromelf.exe --bin -o "output\@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x4000400 size 0xfc00
  link misc: --no_remove
