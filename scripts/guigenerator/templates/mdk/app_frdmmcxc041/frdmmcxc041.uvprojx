# Keil uVision project frdmmcxc041.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MCXC041VFK NXP
  pack: NXP.MCXC041_DFP.17.0.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x0600) IRAM2(0x1FFFFE00,0x0200) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: hello_world
  c flags: Optim=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: CPU_MCXC041VFK DEBUG  KEIL NDEBUG
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: ..\..\..\..\..\devices\MCXC041\arm\MCXC041_flash.scf
target Release (ARM-ADS)
  device: MCXC041 NXP
  pack: NXP.MCXC041_DFP.17.0.0
  cpu: as above
  output: hello_world
  c flags: Optim=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: CPU_MCXC041VFK NDEBUG  KEIL CPU_MCXC041VFK
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: ..\..\..\..\..\devices\MCXC041\arm\MCXC041_flash.scf
