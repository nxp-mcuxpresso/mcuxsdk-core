# Keil uVision project twrk65f180m.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MK65FN2M0xxx18 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MK65FN2M0VMI18, DEBUG,KEIL,TWR_K65F180M, TOWER
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_MK65FN2M0VMI18, DEBUG,__CC_ARM,KEIL,TWR_K65F180M, TOWER
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  link misc: --no_remove
target Release (ARM-ADS)
  device: MK65FN2M0xxx18 Freescale Semiconductor
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MK65FN2M0VMI18, NDEBUG,KEIL,TWR_K65F180M, TOWER
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_MK65FN2M0VMI18, NDEBUG,__CC_ARM,KEIL,TWR_K65F180M, TOWER
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  link misc: --no_remove
