# Keil uVision project app_frdmimxrt700_cm33_core0.uvprojx, settings and files
target Debug (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGVKB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.26.03.00
  cpu: IRAM(0x00080000,0x280000) IRAM2(0x10080000,0x280000) IROM(0x03000000,0x040000) IROM2(0x13000000,0x040000) XRAM(0x20080000,0x280000) XRAM2(0x30080000,0x280000) XRAM3(0x00680000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
target Release (6120000::V6.12::.\ARMCLANG)
  device: MIMXRT798SGVKB:cm33_core0 NXP
  pack: NXP.MIMXRT798S_DFP.26.03.00
  cpu: as above
  output: hello_world
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20080000 size 0x280000
  memory RVCT7: RAM 0x30080000 size 0x280000
  memory RVCT8: RAM 0x680000 size 0x100000
  memory RVCT9: RAM 0x80000 size 0x280000
  memory RVCT10: RAM 0x10080000 size 0x280000
