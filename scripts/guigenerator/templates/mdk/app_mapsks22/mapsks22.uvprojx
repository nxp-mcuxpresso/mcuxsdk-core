# Keil uVision project mapsks22.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  pack: Keil.Kinetis_KSxx_DFP.1.0.0-RC4
  cpu: IROM(0x00000000,0x00040000) IRAM(0x1FFFC000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello_world +hex
  c flags: Optim=1 wLevel=2
  c define: CPU_MKV31F128VLL10 DEBUG __CC_ARM KEIL NDEBUG CPU_MKV31F128VLL10
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: ..\..\..\..\platform\linker\mdk_arm\KV31F12810\KV31F128xxx10_flash.sct
target Release (ARM-ADS)
  device: MKS22FN256xxx12 Freescale
  pack: Keil.Kinetis_KSxx_DFP.1.0.0-RC4
  cpu: as above
  output: hello_world +hex
  c flags: Optim=1 wLevel=2
  c define: CPU_MKL03Z16VFK4 NDEBUG __CC_ARM KEIL CPU_MKL03Z32VFK4
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: ..\..\..\..\platform\linker\mdk_arm\KL03Z4\KL03Z32xxx4_flash.sct
