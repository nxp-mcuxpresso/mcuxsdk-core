# Keil uVision project app_frdmmcxl255.uvprojx, settings and files
target Debug (6180000::V6.18::ARMCLANG)
  device: MCXL255VDF:cm33 NXP
  pack: NXP.MCXL255_DFP.25.06.00
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ ELITTLE
  output: hello_world
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_MCXL255VDF_cm33, MCXL255_cm33_SERIES, DEBUG, MCUX_META_BUILD, MCUXPRESSO_SDK, SDK_DEBUGCONSOLE=1
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,KEIL
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT6: RAM 0x4000000 size 0x2000
  memory RVCT7: RAM 0x14000000 size 0x2000
  memory RVCT8: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x28000000 size 0x10000
  memory RVCT10: RAM 0x28010000 size 0xe000
target Release (6130001::V6.13.1::.\ARMCLANG)
  device: MCXL255VDF NXP
  pack: NXP.MCXL255_DFP.25.06.00
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ ELITTLE
  output: hello_world
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,KEIL
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,KEIL
  memory RVCT1: ROM 0x0 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT6: RAM 0x4000000 size 0x2000
  memory RVCT7: RAM 0x14000000 size 0x2000
  memory RVCT8: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x6000
