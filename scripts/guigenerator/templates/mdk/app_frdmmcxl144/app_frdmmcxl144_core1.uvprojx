# Keil uVision project app_frdmmcxl144_core1.uvprojx, settings and files
target Debug (6180000::V6.18::ARMCLANG)
  device: MCXL144VLL:cm0plus NXP
  pack: NXP.MCXL144_DFP.26.03.00
  cpu: CPUTYPE("Cortex-M0+")
  output: hello_world
  AfterMake: fromelf --bin -o "$L@L.bin" !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_MCXL144VLL_cm0plus, MCXL144_cm0plus_SERIES, DEBUG, MCUX_META_BUILD, MCUXPRESSO_SDK, SDK_DEBUGCONSOLE=1
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,KEIL
  library: MicroLIB
  memory RVCT10: RAM 0x0 size 0x8000
  link misc: --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers --list output.map
target Release (6130001::V6.13.1::.\ARMCLANG)
  device: MCXL144VLL NXP
  pack: NXP.MCXL144_DFP.26.03.00
  cpu: IRAM(0x10000000,0x020000) IRAM2(0x20000000,0x6000) IROM(0x03000000,0x2000) IROM2(0x13000000,0x2000) XRAM(0x04000000,0x2000) XRAM2(0x14000000,0x2000) XRAM3(0x04002000,0x1000) XROM(0x00000000,0x020000) CPUTYPE("Cortex-M33") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,KEIL
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,KEIL
  memory RVCT10: RAM 0x0 size 0x8000
  link misc: as above
