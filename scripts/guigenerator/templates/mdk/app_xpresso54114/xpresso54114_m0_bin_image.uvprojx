# Keil uVision project xpresso54114_m0_bin_image.uvprojx, settings and files
target Debug (ARM-ADS)
  device: LPC54114J256BD64:M0plus NXP
  pack: Keil.LPC54000_DFP.2.0.0
  cpu: CPUTYPE("Cortex-M0+")
  output: hello_world
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bincombined --bincombined_base=0x20010000 --output=$Lcore1_image.bin !L
  c flags: Optim=1 wLevel=2
  c define: CPU_LPC54114J256_M0, DEBUG, KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_LPC54114J256_M0, DEBUG, KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  link misc: --no_remove
target Release (ARM-ADS)
  device: LPC54114J256BD64:M0plus NXP
  pack: Keil.LPC54000_DFP.2.0.0
  cpu: CPUTYPE("Cortex-M0+")
  output: hello_world
  AfterMake: as above
  c flags: Optim=1 wLevel=2
  c define: CPU_LPC54114J256_M0, NDEBUG, KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: CPU_LPC54114J256_M0, NDEBUG, KEIL
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  link misc: --no_remove
