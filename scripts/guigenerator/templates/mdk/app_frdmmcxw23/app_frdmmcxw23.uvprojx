# Keil uVision project app_frdmmcxw23.uvprojx, settings and files
target Debug (6130001::V6.13.1::.\ARMCLANG)
  device: MCXW236BIHNAR NXP
  pack: NXP.MCXW236B_DFP.13.0.0
  cpu: IRAM(0x10000000,0x100000) IRAM2(0x20004000,0x01c000) IROM(0x03000000,0x040000) IROM2(0x13000000,0x040000) XRAM(0x04000000,0x4000) XRAM2(0x14000000,0x4000) XRAM3(0x30004000,0x01c000) XROM(0x00000000,0x0fe000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: hello_world +hex
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --diag_suppress=9931 --bin --output=debug\@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL
  c misc: -Wunused-variable  -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL
  memory RVCT1: ROM 0x0 size 0xfe000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x4000000 size 0x4000
  memory RVCT7: RAM 0x14000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x1c000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x20004000 size 0x1c000
target Release (6130001::V6.13.1::.\ARMCLANG)
  device: MCXW236BIHNAR NXP
  pack: NXP.MCXW236B_DFP.13.0.0
  cpu: as above
  output: hello_world
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --diag_suppress=9931 --bin --output=release\@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL
  memory RVCT1: ROM 0x0 size 0xfe000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x4000000 size 0x4000
  memory RVCT7: RAM 0x14000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x1c000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x20004000 size 0x1c000
