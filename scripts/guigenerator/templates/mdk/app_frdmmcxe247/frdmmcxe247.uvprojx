# Keil uVision project frdmmcxe247.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MCXE247VLQ NXP
  pack: NXP.MCXE247_DFP.25.03.00
  cpu: IRAM(0x14000000,0x1000) IRAM2(0x1ffe0000,0x020000) IROM(0x10000000,0x080000) IROM2(0x00000000,0x180000) XRAM(0x20000000,0x01f000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MCXE247VLQ DEBUG  KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT5: ROM 0x0 size 0x180000
  memory RVCT6: ROM 0x20000000 size 0x1f000
  memory RVCT9: RAM 0x14000000 size 0x1000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: ..\..\..\..\..\platform\linker\arm\MCXE247\MCXE247_flash.scf
target Release (ARM-ADS)
  device: MCXE247 NXP
  pack: NXP.MCXE247_DFP.25.03.00
  cpu: as above
  output: hello_world
  c flags: Optim=1 wLevel=2
  c define: CPU_MCXE247VLL NDEBUG  KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT5: ROM 0x0 size 0x180000
  memory RVCT6: ROM 0x20000000 size 0x1f000
  memory RVCT9: RAM 0x14000000 size 0x1000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: ..\..\..\..\..\platform\linker\arm\MCXE247\MCXE247_flash.scf
