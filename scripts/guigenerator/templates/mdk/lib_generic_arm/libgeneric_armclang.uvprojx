# Keil uVision project libgeneric_armclang.uvprojx, settings and files
target debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  output: platform_lib_debug (library)
  c flags: Optim=1 v6Lang=3 wLevel=2
  c define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
target release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  output: platform_lib_release (library)
  c flags: Optim=1 v6Lang=3
  c define: CPU_MK64FN1M0VMD12, NDEBUG,__CC_ARM,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: NDEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
