# Keil uVision project libgeneric_m0plus.uvprojx, settings and files
target debug (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x0600) IRAM2(0x1FFFFE00,0x0200) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: platform_lib_debug (library)
  c flags: Optim=1 wLevel=2
  c define: CPU_MKL03Z32VFK4, DEBUG,__CC_ARM,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
target release (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: as above
  output: platform_lib_release (library)
  c flags: Optim=1
  c define: CPU_MKL03Z32VFK4, NDEBUG,__CC_ARM,KEIL
  c misc: --c99 --diag_suppress=1296,186
  asm define: NDEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
