# Keil uVision project app_xpresso55s69_core1_bin_image_secure.uvprojx, settings and files
target Debug (ARM-ADS)
  device: LPC55S69JBD100:cm33_core1 NXP
  pack: NXP.LPC55S69_DFP.11.0.0
  cpu: IRAM(0x20000000,0x044000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x098000) XRAM(0x40100000,0x4000) CPUTYPE("Cortex-M33") CLOCK(12000000) ELITTLE
  output: hello_world
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bincombined --bincombined_base=0x30033000 --output=$Lcore1_image.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_LPC55S69JBD100_cm33_core1, DEBUG, KEIL
  asm define: CPU_LPC55S69JBD100_cm33_core1, DEBUG, KEIL
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
target Release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core1 NXP
  pack: NXP.LPC55S69_DFP.11.0.0
  cpu: as above
  output: hello_world
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_LPC55S69JBD100_cm33_core1, NDEBUG, KEIL
  asm define: CPU_LPC55S69JBD100_cm33_core1, NDEBUG, KEIL
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: ROM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
