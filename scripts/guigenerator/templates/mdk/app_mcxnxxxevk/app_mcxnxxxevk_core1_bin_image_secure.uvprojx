# Keil uVision project app_mcxnxxxevk_core1_bin_image_secure.uvprojx, settings and files
target Debug (ARM-ADS)
  device: MCXN947VNL:cm33_core1 NXP
  pack: NXP.MCXN947_DFP.15.0.0
  cpu: IRAM(0x20000000,0x068000) IRAM2(0x04000000,0x018000) IROM(0x03000000,0x040000) IROM2(0x13000000,0x040000) XRAM(0x14000000,0x018000) XRAM2(0x30000000,0x068000) XRAM3(0x400ba000,0x1000) XROM(0x00000000,0x100000) XROM2(0x00100000,0x100000) XROM3(0x10000000,0x100000) CPUTYPE("Cortex-M33") CLOCK(12000000) ELITTLE
  output: hello_world
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bincombined --bincombined_base=0x3004E000 --output=$Lcore1_image.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_LPC55S69JBD100_cm33_core1, DEBUG, KEIL
  asm define: CPU_LPC55S69JBD100_cm33_core1, DEBUG, KEIL
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT3: ROM 0x10000000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x14000000 size 0x18000
  memory RVCT7: RAM 0x30000000 size 0x68000
  memory RVCT8: RAM 0x400ba000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x68000
  memory RVCT10: RAM 0x4000000 size 0x18000
target Release (ARM-ADS)
  device: MCXN947VNL:cm33_core1 NXP
  pack: NXP.MCXN947_DFP.15.0.0
  cpu: as above
  output: hello_world
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_LPC55S69JBD100_cm33_core1, NDEBUG, KEIL
  asm define: CPU_LPC55S69JBD100_cm33_core1, NDEBUG, KEIL
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT3: ROM 0x10000000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: ROM 0x14000000 size 0x18000
  memory RVCT7: ROM 0x30000000 size 0x68000
  memory RVCT8: ROM 0x400ba000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x68000
  memory RVCT10: RAM 0x4000000 size 0x18000
